# Keil uVision project city_wc_plan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: city_wc_plan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 isd4004.h hcsr04.h delay.h LCD12864.h led.h motor.h main.c delay.c LCD12864.c led.c isd4004.c hcsr04.c
